# IAR project GPIO_input.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MK60DN512VLL10
  ICCARM.CCIncludePath2: ..\..\library\device; ..\..\library\driver; ..\..\library\startup\CMSIS; ..\..\library\startup\devicesupport; ..\..\library\startup\devicesupport\utilitis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GPIO_input.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group driver
    ../../library/driver/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_port.h
  group startup
    ../../library/startup/devicesupport/iar/: startup_MK60D10.s
    ../../library/startup/devicesupport/: system_MK60D10.c
  group user
    ./: main.c
  group utilities
    ../../library/startup/devicesupport/utilitis/: fsl_debug_console.c
