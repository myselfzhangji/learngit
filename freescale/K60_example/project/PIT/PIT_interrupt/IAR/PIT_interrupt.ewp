# IAR project PIT_interrupt.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 NXP MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: MK60D10; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\library\startup\coresupport; ..\..\..\..\library\startup\devicesupport; ..\..\..\..\library\startup\devicesupport\IAR_ARM; ..\..\..\..\library\driver\inc; $TOOLKIT_DIR$\inc\c
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: PIT_interrupt.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group doc
    ./: readme.txt
  group drivers
    ../../../../library/driver/src/: common.c gpio.c pit.c
  group startup
    ../../../../library/startup/devicesupport/IAR_ARM/: startup_MK60D10.s
    ../../../../library/startup/devicesupport/: system_MK60D10.c
  group user
    ./: main.c
