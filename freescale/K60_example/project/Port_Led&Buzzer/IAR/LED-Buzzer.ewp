# IAR project LED-Buzzer.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 NXP MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\..\library\startup\coresupport; ..\..\..\library\startup\devicesupport; ..\..\..\library\startup\devicesupport\IAR_ARM
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: LED-Buzzer.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group startup
    ../../../library/startup/devicesupport/IAR_ARM/: startup_MK60D10.s
    ../../../library/startup/devicesupport/: system_MK60D10.c
  group user
    ./: main.c
